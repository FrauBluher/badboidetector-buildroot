## package/badboidetector/Config.in
```kconfig
config BR2_PACKAGE_BADBOIDETECTOR
	bool "badboidetector"
	help
	      bad boy detector for your delight.
```
